# IAR project iDOLPHIN_manufacture.ewp, settings and files
configuration iDOLPHIN_manufacture (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/; ../Drivers/BSP/STM32469I-Discovery; ../Drivers/BSP/Components/n25q128a; ../Drivers/BSP/Components/n25q128a/otm8009a; ../Drivers/BSP/OS/uCOS-III; ../Micrium/Software/uC-CPU; ../Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR; ../Micrium/Software/uC-LIB; ../Micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../Micrium/Software/uCOS-III/Source; ../Src/OS3; ../Utilities/Fonts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: iDOLPHIN_manufacture.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f469xx.s
  group Application/User
    ../Src/: Adafruit_TCS34725.c Adafruit_TSL2591.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c TSL2561.c
  group Application/User/OS3
    ../Src/OS3/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Drivers/BSP
    ../Drivers/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c
  group Drivers/BSP/Components/n25q128a
    ../Drivers/BSP/Components/n25q128a/: n25q128a.h
  group Drivers/BSP/Components/otm8009a
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a.h
  group Drivers/BSP/OS/uCOS-III
    ../Drivers/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group Drivers/BSP/STM32469I-Discovery
    ../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery.h stm32469i_discovery_lcd.c stm32469i_discovery_lcd.h stm32469i_discovery_qspi.c stm32469i_discovery_qspi.h stm32469i_discovery_sdram.c stm32469i_discovery_sdram.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Micrium/Software/uC-CPU
    ../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR
    ../Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group Micrium/Software/uC-LIB
    ../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/IAR
    ../Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group Micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../Micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Micrium/Software/uCOS-III/Source
    ../Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
